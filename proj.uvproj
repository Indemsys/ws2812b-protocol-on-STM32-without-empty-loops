# Keil uVision project proj.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: proj +hex
  c flags: Optim=1
  c misc: --min_array_alignment=8 --pointer_alignment=8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\MemMap.sct
  group App
    ./App/: main.c IO_funcs.c LEDs_strip.c
  group Bsp
    ./Bsp/: cortexm3_macro.s stm32f4xx_DMA.c stm32f4xx_timers.c stm32f4xx_UART.c stm32f4xx_VIC.c system_stm32f4xx.c startup_stm32f4xx.s
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: proj +hex
  c flags: Optim=1
  c misc: --min_array_alignment=8 --pointer_alignment=8
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\proj.sct
